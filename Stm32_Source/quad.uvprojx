# Keil uVision project quad.uvprojx, settings and files
target quad (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quad +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\CMSIS;.\Startup;.\STM32F10x_StdPeriph_Driver\inc;.\User;.\OLED_Lib;.\FreeRTOS_Library\include;.\FreeRTOS_Library\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./User/: main.c main.h
  group startup
    ./Startup/: startup_stm32f10x_md.s
  group lib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group OLED_Lib
    ./OLED_Lib/: fonts.c ssd1306.c iic.c display.c
  group FreeRTOS
    ./FreeRTOS_Library/portable/MemMang/: heap_1.c
    ./FreeRTOS_Library/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS_Library/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
